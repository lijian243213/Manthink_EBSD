# IAR project BST0x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L190FCUA HDSC HC32L190FCUA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\src\T&H\I2C; ..\..\src\T&H\SHT20; ..\..\src\T&H\DS18B20; ..\..\src\T&H\THHook; ..\..\src\T&H; ..\..\src\System; ..\..\src; E:\SVN2.0\RDSoftware\Module\EBSD\src\Sensor\GPS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BST0x.hex
  ILINK.IlinkOutputFile: GPS.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: ..\..\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\LWS429Lib.a; E:\SVN2.0\RDSoftware\Module\EBSD\lib\EBLib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group BST0xHook
    ../../src/Hook/BST0xHook/: BST0xHook.c
  group GPS
    ../../src/Sensor/GPS/: GPS.c
